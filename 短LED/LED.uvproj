# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    F:/金沙滩/14-视频教程-第12章-指针基础与1602液晶的初步认识/第12章-指针基础与1602液晶的初步认识/例程源代码/lesson12_4/: lesson12_4.c
