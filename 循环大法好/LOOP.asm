ORG		0000H
AJMP	MAIN
ORG		0030H
MAIN:MOV	R3,#0FEH
	 MOV	R4,#7FH
	 MOV	R5,#8
	 MOV	R6,#8
LOOP:MOV	P1,R3
	 MOV	A,R3
	 RL		A
	 MOV	R3,A
	 LCALL	DELAY
	 DJNZ	R6,LOOP
	 MOV	R5,#8
LOOP1:MOV	P1,R4
	 MOV	A,R4
	 RR		A
	 MOV	R4,A
	 LCALL  DELAY
	 DJNZ	R5,LOOP1
	 MOV	R6,#8
	 LCALL	LOOP

DELAY:MOV 	R2,#5
LP:	MOV 	R0,#200
LP1:MOV 	R1,#250
	DJNZ 	R1,$
	DJNZ 	R0,LP1
	DJNZ 	R2,LP
	RET	 	
	END